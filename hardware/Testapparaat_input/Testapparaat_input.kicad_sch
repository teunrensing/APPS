File: hardware/Testapparaat_input/Testapparaat_input.kicad_sch (KiCad schematic)
At the start: 34 parts

Commit message: -add bom and new schematic
Parts:
- gave numbers to parts that had none: 34
